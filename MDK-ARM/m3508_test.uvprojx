# Keil uVision project m3508_test.uvprojx, settings and files
target m3508_test (6210000::V6.21::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: m3508_test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../robocon_robot;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../GDUT_ROBOCON;../GDUT_ROBOCON/HARDWARE;../GDUT_ROBOCON/HARDWARE/MOTOR;../GDUT_ROBOCON/CONTROL;../GDUT_ROBOCON/CONTROL/STRUCTURE;..\GDUT_ROBOCON\MATH_LIB
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group robocon_robot
    ../robocon_robot/: crc_util.c crc_util.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group GDUT_ROBOCON
    ../GDUT_ROBOCON/HARDWARE/: TaskManager.cpp TaskManager.h RC9Protocol.cpp RC9Protocol.h Serial_device.cpp Serial_device.h Action.h Acton.cpp can_device.cpp can_device.h
    ../GDUT_ROBOCON/: SIMPLE_TASK.cpp SIMPLE_TASK.h
    ../GDUT_ROBOCON/HARDWARE/MOTOR/: M3508.cpp M3508.h motor.cpp motor.h m6020.cpp m6020.h
    ../GDUT_ROBOCON/CONTROL/: PID.cpp PID.h xbox.cpp xbox.h
    ../GDUT_ROBOCON/CONTROL/STRUCTURE/: chassis.cpp chassis.h
    ../GDUT_ROBOCON/MATH_LIB/: simple_math_tool.c simple_math_tool.h
software components: CMSIS:CORE 5.6.0
